# IAR project Algorithm_bc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __cplusplus
  ICCARM.CCIncludePath2: $PROJ_DIR$; classes\headers; ..\Common\headers; ..\dsol\headers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: Algorithm_bc.out
  ILINK.IlinkIcfFile: D:\Documents\IAR\Algorithm_v2\Algorithm_bc\linker\main_ext.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group classes
    classes/src/: AlgorithmBC.cpp CommController.cpp Global.cpp Hardware.cpp MController.cpp mkpd_bc.cpp PackageController.cpp Packages.cpp
  group Common
    ../Common/src/: startup_irq.s timerdrv.cpp uartdrv.cpp
  group dsol
    ../dsol/src/: mkpd.c system.c timer.c uart.c
  group main
    ./: irqHandler.cpp main.cpp top.cpp
